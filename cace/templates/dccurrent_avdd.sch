** sch_path: cace/templates/dccurrent_avdd.sch
* Copyright 2024 Ajacci, Ltd. Co.
* Apache License, Version 2.0 with Addendum, see NOTICE
**.subckt dccurrent_avdd
Ibias vbp GND 200n
XM1 ibg_200n vbp avdd_bg avdd_bg sky130_fd_pr__pfet_g5v0d10v5 L=4 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM0 vbp vbp avdd_bg avdd_bg sky130_fd_pr__pfet_g5v0d10v5 L=4 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
R1 itest GND 1e6 m=1
C1 outb GND 20p m=1
xIbrout avdd avss outb dvdd osc_ck dvss dcomp vbg_1v2 otrip[2] otrip[1] otrip[0] itest brout_filt
+ vtrip[2] vtrip[1] vtrip[0] vin_brout ena force_ena_rc_osc vin_vunder force_dis_rc_osc timed_out vunder
+ force_short_oneshot isrc_sel ibg_200n sky130_ajc_ip__brownout
Vavss avss GND DC CACE{Vavss}
Vena ena GND DC CACE[CACE{ena}*CACE{Vdvdd}]
Vavdd avdd GND DC CACE{Vavdd}
.save i(vavdd)
Vbg1v2 vbg_1v2 GND DC 1.2
Vdvss dvss GND DC CACE{Vdvss}
Vdvdd dvdd GND DC CACE{Vdvdd}
.save i(vdvdd)
Vvotrip0 otrip[0] GND DC CACE[CACE{otrip[0]}*CACE{Vdvdd}]
.save i(vvotrip0)
Vvotrip1 otrip[1] GND DC CACE[CACE{otrip[1]}*CACE{Vdvdd}]
.save i(vvotrip1)
Vvotrip2 otrip[2] GND DC CACE[CACE{otrip[2]}*CACE{Vdvdd}]
.save i(vvotrip2)
Visrc_sel isrc_sel GND DC CACE[CACE{isrc_sel}*CACE{Vdvdd}]
Vvvtrip0 vtrip[0] GND DC CACE[CACE{vtrip[0]}*CACE{Vdvdd}]
.save i(vvvtrip0)
Vvvtrip1 vtrip[1] GND DC CACE[CACE{vtrip[1]}*CACE{Vdvdd}]
.save i(vvvtrip1)
Vvvtrip2 vtrip[2] GND DC CACE[CACE{vtrip[2]}*CACE{Vdvdd}]
.save i(vvvtrip2)
Vavdd_bg avdd_bg GND DC 3.3
Vforce_dis_rc_osc force_dis_rc_osc GND DC CACE[CACE{force_dis_rc_osc}*CACE{Vdvdd}]
Vforce_short_oneshot force_short_oneshot GND DC CACE[CACE{force_short_oneshot}*CACE{Vdvdd}]
Vforce_ena_rc_osc force_ena_rc_osc GND DC CACE[CACE{force_ena_rc_osc}*CACE{Vdvdd}]
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find trip voltage by ramping Vavdd, both up and down.

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include CACE{DUT_path}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
*.option reltol=5e-5
.option reltol=1e-3
.option abstol=1e-3

.save all



.control
op
set wr_singlescale
let Idd = -I(Vavdd)
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data Idd
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
